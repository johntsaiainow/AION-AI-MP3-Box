# AION AI MP3 Box
# Enable the terminal-based NetworkManager interface.

PACKAGECONFIG:append = " nmtui"
