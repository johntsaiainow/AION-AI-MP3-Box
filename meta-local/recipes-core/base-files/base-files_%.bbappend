hostname:raspberrypi3-64 = "aiy-box-rebirth"
